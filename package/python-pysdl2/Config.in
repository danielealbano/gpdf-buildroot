## package/python-pysdl2/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_PYSDL2
	bool "python-pysdl2"
	depends on BR2_PACKAGE_PYTHON3
	help
	  Pure Python interface for PySDL2
```
